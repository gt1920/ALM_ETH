# Keil uVision project ALM_Motor.uvprojx, settings and files
target ALM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G0B1KBUx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: ALM_Motor_App +hex
  BeforeMake: .\Inc_Build.bat
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: .\After_Build.bat ALM_Motor_App
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../BSP
  memory RVCT4: ROM 0x8002000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fdcan.c spi.c tim.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group BSP
    ../BSP/: Motor.c Systick_Task.c CAN_Comm.c sha256.c Motor_Flash.c LED.c CAN_Motor.c bsp_flash.c stage_status.c stage_status_stub.c aes.c fw_id.c motor_upgrade.c
  group Application/Adjuster
    ../BSP/: adjuster_flash.c adjuster_check.c adjuster_update_task.c adjuster_process_task.c adjuster_idle_task.c
    ../Core/Inc/: adjuster_motor_task.c adjuster_CAN_Poll.c adjuster_can_report.c
    ../Core/Src/: adjuster_app.c adjuster_can.c adjuster_params.c adjuster_motion.c adjuster_identify.c adjuster_autorun.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_fdcan.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
