# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (6220000::V6.22::.\ARMCC_V6.22)
  device: STM32H563VGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x80FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE
  output: Bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ../../Core/Inc;../Inc;../../Drivers/STM32H5xx_HAL_Driver/Inc;../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: Bootloader\Bootloader.sct
  group Startup
    ../../MDK-ARM/: startup_stm32h563xx.s
  group Core
    ../../Drivers/CMSIS/Device/ST/STM32H5xx/Source/Templates/: system_stm32h5xx.c
  group Peripherals
    ../../Core/Src/: octospi.c
  group Bootloader
    ../Src/: boot_main.c boot_ext_flash.c
  group HAL_Driver
    ../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_xspi.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_ll_dlyb.c
software components: CMSIS:CORE 5.6.0
