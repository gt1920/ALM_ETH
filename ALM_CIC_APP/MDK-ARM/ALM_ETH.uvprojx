# Keil uVision project ALM_ETH.uvprojx, settings and files
target ALM_ETH (6220000::V6.22::.\ARMCC_V6.22)
  device: STM32H563VGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x80FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE
  output: ALM_ETH +hex
  BeforeMake: .\Inc_Build.bat
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: .\After_Build.bat ALM_ETH
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ../Core/Inc;../BSP;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/netif
  memory RVCT4: ROM 0x8008000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  scatter file: ALM_ETH\ALM_ETH.sct
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dcache.c eth.c bsp_lan8742.c lwip_app.c ethernetif.c sys_arch.c fdcan.c icache.c linked_list.c octospi.c usb.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_eth.c stm32h5xx_hal_eth_ex.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_icache.c stm32h5xx_hal_xspi.c stm32h5xx_ll_dlyb.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Middlewares/LwIP/core
    ../Middlewares/Third_Party/LwIP/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
  group Middlewares/LwIP/core/ipv4
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/api
    ../Middlewares/Third_Party/LwIP/src/api/: err.c
  group Middlewares/LwIP/netif
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group BSP
    ../BSP/: tcp_server.c CAN_comm.c comm_protocol.c eth_send_queue.c systick_task.c udp_discovery.c device_config.c bsp_w25q16.c cpu_id.c fw_id.c upgrade_handler.c aes.c module_upgrade.c
software components: CMSIS:CORE 4.3.0
